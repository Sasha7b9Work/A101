# Keil uVision project arm_fir_example.uvprojx, settings and files
target ARMCM4_FP (6160000::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: arm_fir_example
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_CM4 __FPU_PRESENT=1U, STM32F407xx
  c include: ..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: math_helper.c arm_fir_data.c arm_fir_example_f32.c startup_stm32f407xx.s system_stm32f4xx.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:DSP 1.10.0
