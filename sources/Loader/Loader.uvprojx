# Keil uVision project Loader.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: A101-D
  AfterMake: c:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin Objects-Debug\A101-D.axf --output A101-D.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx, DEBUG
  c include: .\src;.\src\libs\CMSIS;.\src\Hardware\HAL;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;.\src\Hardware\FatFS;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;.\src\Hardware\USBH;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\src\Hardware\USBD;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\sources;..
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group libs/HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_tim.h stm32f4xx_hal_dma.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f407xx.s system_stm32f4xx.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL.cpp HAL_IT.cpp HAL_PIO.cpp HAL_PIO.h stm32f4xx_hal_conf.h HAL_PINS.h HAL_TIM.cpp HAL_USART3.cpp HAL_EEPROM.cpp HAL_CRC32.cpp HAL_TIM2.cpp HAL_TIM3.cpp
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c
  group src
    ./src/: defines.h main.cpp stm_includes.h Device.cpp Device.h Updater.cpp Updater.h
  group SCPI
    ./src/SCPI/: SCPI.cpp SCPI.h SCPI.txt Commands.h Commands.cpp
  group Utils
    ./src/Utils/: Buffer.h String.cpp String.h
target Release (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: as above
  output: A101 +hex
  AfterMake: c:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin Objects\A101.axf --output A101.bin
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx
  c include: .\src;.\src\libs\CMSIS;.\src\Hardware\HAL;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;.\src\Hardware\FatFS;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;.\src\Hardware\USBH;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\src\Hardware\USBD;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\sources;..;..\common\libs\STM32Cube_F4\Drivers\CMSIS\DSP\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
